# Repository CANBus-Triple/CANBus-Triple-Hardware

File README.md:

CANBus-Triple-Hardware
======================

Eagle CAD files for CANBus Triple Hardware

## EAGLE design CANBusTriple_f.brd

Parts:
A2, A3: WIREPADSMD1,27-254; SMD1,27-2,54
BOOT: LEDSMT1206; 1206
BT: LEDSMT1206; 1206
C1, C3, C4, C8: 1uF; C0603
C2: 2.2uF; C0603
C5, C9: 0.1uF; C0603
C7, C10, C12, C13: 20pF; C0603
CC1, CC2, CC3: MCP2515SO; SO-18W
CN1: USBMINIB; USB-MINIB
CT1, CT2, CT3: MCP2551SO8; SO08
D1: DIODESOD-323F; SOD-323F
D6: WIREPADSMD1,27-254; SMD1,27-2,54
IC1: TPS709-50; SOT23-5
IC4: MCP1703CB; SOT23
IC6: IC_MEM_23LC1024; SOIC-8
JP1: 2X6-2.54MM
PWR: LEDSMT1206; 1206
Q0, Q2: 16mhz; SMARTPRJ_CRYSTAL-3.2-2.5
Q1: MOSFET-NCHANNEL2N7002PW; SOT323
R1, R2, R3, R4, R5, R6, R10, R12, R13: 10k; M0805
R7, R8: 22ohm; M0805
R9, R11: 5k; M0805
R14, R15, R16: 120ohm; R0603
S1: SWITCH-MOMENTARY-2SMD; TACTILE_SWITCH_SMD
SJ2: TERM1; SJ_2S-NO
SJ3: TERM2; SJ_2S-NO
SJ4: TERM3; SJ_2S-NO
U1: BLE112; SF-BLUEGIGA_BLE112-A
U$1: ATMEGA32U4-AU; TQFP44
U$10: 2X9-1.27MM-HEADER

Connections:
+3V: C4.1, IC4.2 (VO), U1.AVDD1 (AVDD), U1.AVDD2 (AVDD), U1.DVDD, U$10.2 (VOLTAGE_SENSE), U$10.9 (VCC)
+5V: C2.1, C3.1, C5.1, C9.1, CC1.18 (VCC), CC2.18 (VCC), CC3.18 (VCC), CT1.3 (VCC), CT2.3 (VCC), CT3.3 (VCC), D1.C, IC1.5 (VO), IC4.3 (VI), IC6.8 (V+), R4.2, U$1.14 (VCC), U$1.24 (AVCC), U$1.34 (VCC1), U$1.44 (AVCC1), U$10.14 (MCU-VCC)
+12V: C1.1, IC1.1 (VI), JP1.2
A0: JP1.9, U$1.36 (PF7(ADC7(TDI))
A1: JP1.10, U$1.37 (PF6(ADC6/TDO))
A4: JP1.11, U$1.40 (PF1(ADC1))
A5: JP1.12, U$1.41 (PF0(ADC0))
BLE-112-P0_2: U1.P0_2, U$10.10 (MISO)
BLE-112-P0_3: U1.P0_3, U$10.8 (MOSI)
BLE-112-P0_4: U1.P0_4, U$10.5 (CSN)
BLE-112-P0_5: U1.P0_5, U$10.6 (SCLK)
BLE-112-P1_2: U1.P1_2
BLE-112-P1_3: U1.P1_3
BLE-112-P1_5: U1.P1_5, U$1.22 (PD5(XCK/CTS))
BLE-112-P2_1: U1.P2_1, U$10.4 (DD)
BLE-112-P2_2: U1.P2_2, U$10.3 (DC)
BT_RESET: U1.RESET, U$10.7 (RESET)
CAN1HIGH: CT1.7 (CANH), JP1.3, SJ2.2
CAN1LOW: CT1.6 (CANL), JP1.4, R14.1
CAN1_CLKOUT: CC1.3 (CLKOUT), CC2.8 (OSC1), CC3.8 (OSC1)
CAN1_INT: CC1.12 (INT), Q1.3 (D), U$1.18 (PD0(INT0/OC0B/SCL))
CAN1_OSC2: C10.1, CC1.7 (OSC2), Q2.3
CAN2HIGH: CT2.7 (CANH), JP1.5, SJ3.2
CAN2LOW: CT2.6 (CANL), JP1.6, R15.1
CAN2_INT: CC2.12 (INT), U$1.19 (PD1(INT1/SDA))
CAN3HIGH: CT3.7 (CANH), JP1.7, SJ4.2
CAN3LOW: CT3.6 (CANL), JP1.8, R16.1
CAN3_INT: CC3.12 (INT), U$1.1 (PE6(INT.6/AIN0))
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C7.2, C8.2, C9.2, C10.2, C12.2, C13.2, CC1.9 (GND), CC2.9 (GND), CC3.9 (GND), CN1.GND, CT1.2 (GND), CT2.2 (GND), CT3.2 (GND), IC1.2 (GND), IC4.1 (GND), IC6.4 (GND), JP1.1, Q0.2 (GND), Q0.4 (GND), Q1.2 (S), Q2.2 (GND), Q2.4 (GND), R1.1, R2.1, R3.1, R5.1, R6.1, R10.1, R12.1, R13.1, S1.1, U1.GND1 (GND), U1.GND2 (GND), U1.GND3 (GND), U1.GND4 (GND), U1.P1_4, U$1.5 (UGND), U$1.15 (GND), U$1.23 (GND1), U$1.35 (GND2), U$1.43 (GND3), U$10.1 (GND), U$10.18 (MCU-GND)
HWB: PWR.A, U$1.33 (PE2(!HWB))
MCU-CS: U$1.8 (PB0(SS)), U$10.12 (CS)
MCU_RESET: R4.1, S1.3 (2), U$1.13 (/RESET), U$10.17 (MCU-RESET)
MISO: CC1.15 (SO), CC2.15 (SO), CC3.15 (SO), IC6.2 (SO/SIO1), U$1.11 (PB3(PDO/MISO)), U$10.13 (MCU-MISO)
MOSI: CC1.14 (SI), CC2.14 (SI), CC3.14 (SI), IC6.5 (SI/SIO0), U$1.10 (PB2(PDI/MOSI)), U$10.16 (MCU-MOSI)
unnamed: A2.1, U$1.38 (PF5(ADC5/TMS))
unnamed: C13.1, Q0.1, U$1.17 (XTAL1)
unnamed: CC1.10 (RX1BF), CT1.8 (RS), R1.2
unnamed: CC2.10 (RX1BF), CT2.8 (RS), R2.2
unnamed: BOOT.C, R3.2
unnamed: CC3.1 (TXCAN), CT3.1 (TXD)
unnamed: CC1.1 (TXCAN), CT1.1 (TXD)
unnamed: CC1.2 (RXCAN), CT1.4 (RXD)
unnamed: CC2.1 (TXCAN), CT2.1 (TXD)
unnamed: CC2.2 (RXCAN), CT2.4 (RXD)
unnamed: CC3.2 (RXCAN), CT3.4 (RXD)
unnamed: CC3.10 (RX1BF), CT3.8 (RS), R5.2
unnamed: A3.1, U$1.39 (PF4(ADC4/TCK))
unnamed: R8.1, U$1.3 (D-)
unnamed: R7.1, U$1.4 (D+)
unnamed: R11.2, U$1.21 (PD3(INT3/TXD1))
unnamed: C12.1, Q0.3, U$1.16 (XTAL2)
unnamed: CC2.17 (RESET), U$1.26 (PD6(T1/ADC9/!OC4D))
unnamed: CN1.D+, R7.2
unnamed: CN1.D-, R8.2
unnamed: R9.1, R13.2, U1.P1_0
unnamed: CC1.17 (RESET), U$1.25 (PD4(ICP1/ADC8))
unnamed: CC2.16 (CS), U$1.30 (PB6(OC1B/OC4B/ADC13))
unnamed: Q1.1 (G), U1.P0_1
unnamed: R9.2, U$1.28 (PB4(ADC11))
unnamed: CC1.16 (CS), U$1.29 (PB5(OC1A/ADC12/!OC4B))
unnamed: R10.2, R11.1, U1.P1_7
unnamed: CC3.17 (RESET), U$1.12 (PB7(OC0A/OC1C/RTS))
unnamed: BOOT.A, U$1.32 (PC7(ICP3/CLK0/OC4A))
unnamed: CC3.16 (CS), U$1.31 (PC6(OC3A/!OC4A))
unnamed: C7.1, CC1.8 (OSC1), Q2.1
unnamed: U1.P1_6, U$1.20 (PD2(INT2/RXD1))
unnamed: BT.A, U1.P0_0
unnamed: R14.2, SJ2.1
unnamed: D6.1, IC6.1 (!CS), U$1.27 (PD7(OC4D/ADC10/T0))
unnamed: C8.1, U$1.6 (UCAP)
unnamed: R15.2, SJ3.1
unnamed: PWR.C, R6.2
unnamed: R16.2, SJ4.1
unnamed: BT.C, R12.2
SCK: CC1.13 (SCK), CC2.13 (SCK), CC3.13 (SCK), IC6.6 (SCK), U$1.9 (PB1(SCK)), U$10.15 (MCU-SCLK)
VBUS: CN1.VBUS, D1.A, U$1.2 (UVCC), U$1.7 (VBUS)
VDD_USB: U1.VDD_USB

Board: 2 copper layers, 50.2 x 49.5 mm, 59 parts (24 on the bottom side), 74 nets.

Other parts of the board:
U$4: DETROIT2
U$5, U$6: CANBUS-TRIPLE
U$8: OSHW-LOGO-S

## Commit log

2014-10-14 Adding Eagle Files
2014-10-14 Adding MCP2551 sleep lines - Rs
2014-10-18 switching to single direction LLC to remove MOSFETs
2014-10-18 switched UART Tx from MCU to BLE to simple unidirectional logic level conversion
2014-10-22 Last sleep mode tweak, added line from BT LE to CAN1INT to wake the MCU up via BT
2014-11-02 Fix missing trace on inductor
2014-11-05 switched to LM3480IM3-5.0
2014-11-05 switched to TPS70950 LDO Linear Regulator
2014-11-06 Add Schematic PDF and ignore eagle pref file
2014-12-11 Some part name changes
2016-12-27 Adding Digikey BOM
2017-06-19 Added missing BOM parts and removed unnecessary columns

Notices in the files:
parts and their libraries:
SparkFun: Licensing: CC v3.0 Share-Alike You are welcome to use this library for commercial purposes.
